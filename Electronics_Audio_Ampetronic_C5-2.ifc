Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-10-15T15:22:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Alternate UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 15 15:22:27 2021 * Host: JCLAP21HP * Database: C:\Users\JODIEC~1\AppData\Local\Temp\{636AC420-02EF-4395-ACAC-B8646D34BCD5}\ifc * Database version: 5507 * Database creation date: Fri Oct 15 15:22:27 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 15 15:22:27 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 15 15:22:27 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Electronics_Audio_Ampetronic_C5-2_120V, Electronics_Audio_Ampetronic_C5-2:Electronics_Audio_Ampetronic_C5-2_120V:318251
In: Level 0
Type - Material: Generic, Blue, Zintex, RAL 7021, Generic, Black, Steel, Black, Aluminum, Brushed
Pset_BuildingElementProxyCommon - Reference: Electronics_Audio_Ampetronic_C5-2_120V
Pset_ManufacturerTypeInformation - Manufacturer: Ampetronic
